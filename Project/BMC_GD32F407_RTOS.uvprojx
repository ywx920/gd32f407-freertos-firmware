# Keil uVision project BMC_GD32F407_RTOS.uvprojx, settings and files
target GD32F407ZGT6 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BMC_GD32F407_RTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: -O1 -g -W
  c include: ..\GDlib\Firmware\CMSIS\GD\GD32F4xx\Include;..\GDlib\Firmware\GD32F4xx_standard_peripheral\Include;..\Rtos\include;..\GDlib\Firmware\CMSIS;..\User;..\FreeRtos_config;..\Rtos\portable\RVDS\ARM_CM4F;..\Bsp\8.GPIO;..\Bsp\0.SYSTICK;..\Letter_shell\src;..\Letter_shell\port;..\Bsp\3.USART;..\Bsp\6.ADC;..\Bsp\19.NST175;..\Bsp\20.Simulate_IIC;..\Bsp;..\Bsp\11.XC6S;..\Net\lwip-2.2.0\src\include\netif;..\Net\lwip-2.2.0\src\include\lwip;..\Net\lwip-2.2.0\src\include;..\Net\lwip-config;..\Net\lwip-arch;..\Net\lwip-app\lwip_comm;..\Bsp\5.ENET;..\Protocol\3.mmu;..\Net\lwip-config;..\Rtos\include;..\Bsp\14.IPMB;..\Bsp\7.IIC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep shellCommand*
  group Bsp
    ../Bsp/0.SYSTICK/: delay.c
    ../Bsp/8.GPIO/: bsp_gpio.c
    ../Bsp/3.USART/: bsp_uart.c
    ../Bsp/6.ADC/: bsp_adc.c
    ../Bsp/20.Simulate_IIC/: simulate_iic.c
    ../Bsp/19.NST175/: bsp_nst175.c
    ../Bsp/22.EEPROM/: i2c_ee.c i2c_gpio.c
    ../Bsp/18.COMCPU/: commcpu.c
    ../Bsp/23.COMFPGA/: commfpga.c
    ../Bsp/11.XC6S/: bsp_Control_xc6s.c
    ../Bsp/15.myString/: myString.c
    ../Bsp/5.ENET/: bsp_phy_YT8512H.c
    ../Bsp/14.IPMB/: ipmb.c
    ../Bsp/7.IIC/: bsp_i2c.c
  group GDlib
    ../GDlib/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Rtos
    ../Rtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Rtos/portable/MemMang/: heap_4.c
    ../Rtos/portable/RVDS/ARM_CM4F/: port.c
  group StartUp
    ../GDlib/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Protocol
    ../Protocol/3.mmu/: malloc.c
  group CMSIS
    ../GDlib/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Letter-shell
    ../Letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Letter_shell/port/: shell_port.c
  group Lwip-core
    ../Net/lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c lwip_sys.c
    ../Net/lwip-2.2.0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip-api
    ../Net/lwip-2.2.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c if_api.c sockets.c
  group Lwip-netif
    ../Net/lwip-2.2.0/src/netif/: ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Lwip-arch
    ../Net/lwip-arch/: sys_arch.c
    ../Net/lwip-config/: ethernetif.c
  group Lwip-app
    ../Net/lwip-config/: lwip_client.c
